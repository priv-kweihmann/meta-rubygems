EXTRA_OECONF += "\
    --disable-versioned-paths \
    "
